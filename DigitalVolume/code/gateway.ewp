# IAR project gateway.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: N76E003 N76E003
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: .\include; .\libs; .\src
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Nuvoton\lnk51ew_N76E003.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group inc
    include/: Function_define.h N76E003_iar.h SFR_Macro.h
  group libs
    libs/: Common.c Common.h Delay.c Delay.h soft_delay.c soft_delay.h
  group src
    src/: buttons.c buttons.h encoder.c encoder.h ir.c ir.h serial.c serial.h volume.c volume.h
    libs/: globals.h
